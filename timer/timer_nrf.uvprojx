# Keil uVision project timer_nrf.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.1
  cpu: IROM(0x00000000,0x00030000) IRAM(0x20000000,0x00006000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: timer_nrf
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Source Group 1
    ./: main.c timer.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.27.1, Device:StartupConfig 8.27.1
